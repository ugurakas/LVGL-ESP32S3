## tests/config_store/testcase.yaml
```yaml
tests:
  iot.config_store:
    platform_allow:
      - native_sim/native/64
    tags:
      - settings
      - iot
```
